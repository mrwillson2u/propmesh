// BRMesh ("fastcon") BLE flood lights: build the advertisement that sets
// one light's colour. The lights listen for BLE advertisements with
// manufacturer id 0xFFF0 carrying a whitened, key-XORed, CRC'd 24-byte
// payload — no pairing, no connection, nothing comes back.
//
// Ported from Colin's working BRMeshToMQTT code and from
// dsclee1/BRmesh-esp32-mqtt (which adds pairing), without their mallocs;
// pm_brmesh tests compare the output byte-for-byte with the latter.
// NOTE: reference/brmesh-to-mqtt was scrubbed too hard — its default_key
// is zeroed; the real protocol constant is 5E 36 7B C4 (found 2026-10-06).
//
// Frame classes: 0 = wake/scan (no key), 2 = add device (pairing, sent
// with the default key), 5 = light control (the network key).
// The 4-byte network key is generated by the node at first pairing and
// lives only in its config.
// Header-only, no Arduino/ESP includes: tested host-native.
#pragma once
#include <stdint.h>
#include <string.h>

#define PM_BRMESH_ADV_LEN 31

namespace pm_brmesh {

static const uint8_t ADDR[3] = {0xC1, 0xC2, 0xC3};  // DEFAULT_BLE_FASTCON_ADDRESS
// Scrambles every frame's header; also the key an unpaired light uses.
static const uint8_t DEFAULT_KEY[4] = {0x5E, 0x36, 0x7B, 0xC4};

inline uint8_t rev8(uint8_t d) {
  uint8_t r = 0;
  for (uint8_t k = 0; k < 8; k++) r |= ((d >> k) & 1) << (7 - k);
  return r;
}

inline uint16_t rev16(uint16_t d) {
  uint16_t r = 0;
  for (uint8_t k = 0; k < 16; k++) r |= ((d >> k) & 1) << (15 - k);
  return r;
}

inline void crc_step(uint16_t &crc) {
  for (uint8_t ii = 0; ii < 4; ii++) {
    uint16_t tmp = crc << 1;
    if (crc & 0x8000) tmp ^= 0x1021;
    crc = tmp << 1;
    if (tmp & 0x8000) crc ^= 0x1021;
  }
}

inline uint16_t crc16(const uint8_t *data, uint8_t len) {
  uint16_t crc = 0xffff;
  for (int8_t i = 2; i >= 0; i--) { crc ^= ADDR[i] << 8; crc_step(crc); }
  for (uint8_t i = 0; i < len; i++) { crc ^= rev8(data[i]) << 8; crc_step(crc); }
  return ~rev16(crc) & 0xffff;
}

inline void whiten(uint8_t *buf, int len) {
  uint8_t ctx[7] = {1, (0x25 >> 5) & 1, (0x25 >> 4) & 1, (0x25 >> 3) & 1, (0x25 >> 2) & 1, (0x25 >> 1) & 1, 0x25 & 1};
  for (int i = 0; i < len; i++) {
    int varC = ctx[3], var14 = ctx[5], var18 = ctx[6], var10 = ctx[4];
    int var8 = var14 ^ ctx[2], var4 = var10 ^ ctx[1], v = var18 ^ varC, var0 = v ^ ctx[0];
    int c = buf[i];
    buf[i] = ((c & 0x80) ^ ((var8 ^ var18) << 7)) + ((c & 0x40) ^ (var0 << 6)) +
             ((c & 0x20) ^ (var4 << 5)) + ((c & 0x10) ^ (var8 << 4)) + ((c & 0x08) ^ (v << 3)) +
             ((c & 0x04) ^ (var10 << 2)) + ((c & 0x02) ^ (var14 << 1)) + ((c & 0x01) ^ (var18 << 0));
    ctx[2] = var4; ctx[3] = var8; ctx[4] = var8 ^ varC; ctx[5] = var0 ^ var10;
    ctx[6] = var4 ^ var14; ctx[0] = var8 ^ var18; ctx[1] = var0;
  }
}

}  // namespace pm_brmesh

// The 6-byte light command:
//   off/brightness: {0x22, light, brightness 0..127, 0, 0, 0}
//   colour:         {0x72, light, brightness 0..127, blue, red, green}
inline void pm_brmesh_command(uint8_t light, uint32_t rgb, uint8_t out[6]) {
  uint8_t r = rgb >> 16, g = rgb >> 8, b = rgb;
  uint8_t peak = r > g ? (r > b ? r : b) : (g > b ? g : b);
  memset(out, 0, 6);
  out[1] = light;
  if (!peak) { out[0] = 0x22; return; }  // black = off
  // Brightness from the colour's peak; the colour itself sent at full
  // scale, so a dim red is "red at low brightness", as the lights expect.
  out[0] = 0x72;
  out[2] = (uint8_t)((peak * 127 + 127) / 255);
  out[3] = (uint8_t)((b * 255 + peak / 2) / peak);
  out[4] = (uint8_t)((r * 255 + peak / 2) / peak);
  out[5] = (uint8_t)((g * 255 + peak / 2) / peak);
}

// One fastcon frame as a 31-byte BLE advertising payload.
// `cls`: 0 wake, 2 add device, 5 control. `key` all zero = no key (wake):
// the data bytes are then replaced by the default key, as the app does.
inline void pm_brmesh_frame(uint8_t cls, bool forward, const uint8_t key[4], uint8_t seq,
                            const uint8_t *data, uint8_t len, uint8_t adv[PM_BRMESH_ADV_LEN]) {
  using namespace pm_brmesh;
  bool has_key = key[0] | key[1] | key[2] | key[3];
  uint8_t body[16] = {};
  body[0] = (cls & 7) << 4 | (forward ? 0x80 : 0);
  body[1] = seq;
  body[2] = has_key ? key[3] : 0xFF;
  if (len > 12) len = 12;
  memcpy(body + 4, data, len);
  uint8_t sum = 0;
  for (int j = 0; j < len + 4; j++) if (j != 3) sum += body[j];
  body[3] = sum;
  for (int j = 0; j < 4; j++) body[j] ^= DEFAULT_KEY[j];
  for (int j = 0; j < 12; j++) body[4 + j] ^= key[j & 3];
  if (!has_key) for (int j = 0; j < 12; j++) body[4 + j] = DEFAULT_KEY[j & 3];

  // rf frame: preamble 71 0F 55 · address (reversed) · body · crc
  uint8_t rf[39] = {};
  rf[15] = 0x71; rf[16] = 0x0F; rf[17] = 0x55;
  for (int j = 0; j < 3; j++) rf[18 + 3 - j - 1] = ADDR[j];
  memcpy(rf + 21, body, 16);
  for (int i = 15; i < 21; i++) rf[i] = rev8(rf[i]);
  uint16_t crc = crc16(body, 16);
  rf[37] = crc & 0xff;
  rf[38] = crc >> 8;
  whiten(rf, 39);

  // advertisement: flags (BR/EDR not supported) · manufacturer 0xFFF0 · rf[15..38]
  static const uint8_t HEAD[7] = {0x02, 0x01, 0x04, 0x1B, 0xFF, 0xF0, 0xFF};
  memcpy(adv, HEAD, 7);
  memcpy(adv + 7, rf + 15, 24);
}

// Light control (class 5, forwarded through the lights' own mesh).
inline void pm_brmesh_adv(const uint8_t key[4], uint8_t seq, const uint8_t cmd[6],
                          uint8_t adv[PM_BRMESH_ADV_LEN]) {
  pm_brmesh_frame(5, true, key, seq, cmd, 6, adv);
}

// Wake: makes unpaired lights advertise themselves (class 0, no key).
inline void pm_brmesh_wake(uint8_t seq, uint8_t adv[PM_BRMESH_ADV_LEN]) {
  static const uint8_t zero[6] = {}, nokey[4] = {};
  pm_brmesh_frame(0, false, nokey, seq, zero, 6, adv);
}

// Add device: tell the light with `light_mac` (as it reported it) to join
// with `key`, as light number `number`, group 1. The frame is encoded with
// the key the light holds now: DEFAULT_KEY for an unpaired light; the key
// it advertises for one paired to another controller (take-over).
inline void pm_brmesh_add(const uint8_t light_mac[6], uint8_t number, const uint8_t key[4],
                          uint8_t seq, uint8_t adv[PM_BRMESH_ADV_LEN],
                          const uint8_t cur_key[4] = pm_brmesh::DEFAULT_KEY) {
  uint8_t d[12];
  memcpy(d, light_mac, 6);
  d[6] = number;
  d[7] = 0x01;
  memcpy(d + 8, key, 4);
  pm_brmesh_frame(2, false, cur_key, seq, d, 12, adv);
}

// A light's own advertisement (manufacturer data, 18 bytes including the
// 2-byte company id) while it is being found / paired. Bytes 6..17 are
// XORed with the key the light holds (so the key slot, zero underneath,
// reads as the key itself). Lights advertise from a shared placeholder
// Bluetooth address (11:22:33:44:55:66 seen 2026-10-07), so a light's
// identity is the key-independent part of this data, never the address.
struct PmBrmeshSeen {
  uint8_t mac[6];   // what the add-device command must quote
  uint8_t type[2];  // A0 A8 RGB · A1 A8 RGBW · 39 AE smart (on/off)
  uint8_t key[4];   // DEFAULT_KEY while unpaired; otherwise the key it holds
};

inline bool pm_brmesh_parse(const uint8_t *mdata, uint8_t len, PmBrmeshSeen &out) {
  if (len != 18) return false;
  memcpy(out.mac, mdata + 6, 6);
  memcpy(out.type, mdata + 12, 2);
  memcpy(out.key, mdata + 14, 4);
  return true;
}

inline bool pm_brmesh_unpaired(const PmBrmeshSeen &s) { return !memcmp(s.key, pm_brmesh::DEFAULT_KEY, 4); }

// Bytes 6..17 with the light's key XORed back out (dsclee1's
// cleanManufacturerData): [1] = its light number, [8..11] = 0.
inline void pm_brmesh_clean(const uint8_t *mdata, const uint8_t key[4], uint8_t out[12]) {
  for (uint8_t j = 0; j < 12; j++) out[j] = mdata[6 + j] ^ key[j & 3];
}
// What identifies a light across a key change: clean bytes 0..7 without
// [1], its light number, which pairing changes too.
inline void pm_brmesh_id(const uint8_t *mdata, const uint8_t key[4], uint8_t id[8]) {
  uint8_t c[12];
  pm_brmesh_clean(mdata, key, c);
  c[1] = 0;
  memcpy(id, c, 8);
}
// Type bytes as an unpaired light shows them (the codes below were read
// off unpaired lights, i.e. XORed with the default key).
inline void pm_brmesh_type_norm(const PmBrmeshSeen &s, uint8_t t[2]) {
  t[0] = s.type[0] ^ s.key[2] ^ pm_brmesh::DEFAULT_KEY[2];
  t[1] = s.type[1] ^ s.key[3] ^ pm_brmesh::DEFAULT_KEY[3];
}

// After pairing, the light's number, read back with our key.
inline uint8_t pm_brmesh_number(const uint8_t *mdata, const uint8_t key[4]) { return key[1] ^ mdata[7]; }

inline const char *pm_brmesh_type_name(const uint8_t t[2]) {
  if (t[0] == 0xA0 && t[1] == 0xA8) return "RGB";
  if (t[0] == 0xA1 && t[1] == 0xA8) return "RGBW";
  if (t[0] == 0x39 && t[1] == 0xAE) return "on/off";
  return "unknown";
}
inline const char *pm_brmesh_type_name(const PmBrmeshSeen &s) {
  uint8_t t[2];
  pm_brmesh_type_norm(s, t);
  return pm_brmesh_type_name(t);
}
